# IAR project isp.ewp, settings and files
configuration Release (AVR32)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allaf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1100; ISP_OSC=0
  ICCAVR32.CCIncludePath2: ..\..\..\..\..\..\..\..\BOARDS\; ..\..\..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\..\..\..\..\..\..\SERVICES\MEMORY\CTRL_ACCESS\; ..\..\..\..\..\..\..\..\SERVICES\FAT\; ..\..\..\..\..\..\..\..\DRIVERS\PM\; ..\..\..\..\..\..\..\..\DRIVERS\WDT\; ..\..\..\..\..\..\..\..\DRIVERS\FLASHC\; ..\..\..\..\..\..\..\..\DRIVERS\USBB\; ..\..\..\..\..\..\..\..\DRIVERS\USBB\ENUM\; ..\..\..\..\..\..\..\..\DRIVERS\USBB\ENUM\HOST\; ..\..\..\..\..\..\..\..\SERVICES\USB\; ..\..\..\..\SCSI_DECODER\; ..\..\..\..\HOST_MEM\; ..\..\; ..\..\CONF\; ..\..\BOOT\; ..\..\INTC\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.AIncludePaths: ..\..\..\..\..\..\..\..\UTILS\; ..\..\..\..\..\..\..\..\UTILS\PREPROCESSOR\; ..\..\CONF\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  postbuild: cmd /c cd $PROJ_DIR$ && sh post-build.sh
  XLINK.XclFile: lnkuc3a0512-isp.xcl
  group (top)
    ../../BOOT/: boot.s82
    ../../: crc32.c host_mass_storage_task.c isp.c
    ../../INTC/: intc.c
  group Drivers
    ../../: flashc.c
    ../../../../../../../../DRIVERS/PM/: pm.c
  group Drivers/USBB
    ../../../../../../../../DRIVERS/USBB/: usb_drv.c
  group Drivers/USBB/Enum
    ../../../../../../../../DRIVERS/USBB/ENUM/: usb_task.c
  group Drivers/USBB/Enum/Host
    ../../../../../../../../DRIVERS/USBB/ENUM/HOST/: usb_host_enum.c usb_host_task.c
  group FAT
    ../../../../../../../FAT/: fat.c fat_unusual.c file.c navigation.c
  group Memory
    ../../../../../../../MEMORY/CTRL_ACCESS/: ctrl_access.c
  group USB Mass Storage
    ../../../../HOST_MEM/: host_mem.c
    ../../../../SCSI_DECODER/: scsi_decoder.c
